/*
 * Copyright (C) 2020 Southern Storm Software, Pty Ltd.
 *
 * Permission is hereby granted, free of charge, to any person obtaining a
 * copy of this software and associated documentation files (the "Software"),
 * to deal in the Software without restriction, including without limitation
 * the rights to use, copy, modify, merge, publish, distribute, sublicense,
 * and/or sell copies of the Software, and to permit persons to whom the
 * Software is furnished to do so, subject to the following conditions:
 *
 * The above copyright notice and this permission notice shall be included
 * in all copies or substantial portions of the Software.
 *
 * THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS
 * OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
 * FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
 * AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
 * LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING
 * FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER
 * DEALINGS IN THE SOFTWARE.
 */

#include "internal-sparkle.h"
#include "test-cipher.h"
#include <stdio.h>
#include <string.h>

/* Test vectors for SPARKLE generated with the reference code */
static unsigned char const sparkle256_input[] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f
};
static unsigned char const sparkle256_output[] = {
    0x4a, 0x1c, 0x59, 0xa2, 0x96, 0xfe, 0xae, 0xf7,
    0x52, 0x9f, 0x19, 0xec, 0x1e, 0x66, 0x34, 0x1b,
    0x4c, 0xa2, 0x0e, 0xc8, 0x70, 0xee, 0x03, 0x43,
    0x31, 0xef, 0x69, 0x57, 0x76, 0x72, 0x1e, 0x34
};
static unsigned char const sparkle384_input[] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f,
    0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27,
    0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x2d, 0x2e, 0x2f
};
static unsigned char const sparkle384_output[] = {
    0xc3, 0xb3, 0x56, 0xd6, 0x38, 0x37, 0x68, 0x21,
    0xdb, 0xc1, 0x03, 0x67, 0x82, 0xea, 0x95, 0xa3,
    0xf0, 0xfd, 0xd1, 0x0d, 0x08, 0x4f, 0xa0, 0x93,
    0xa9, 0x7d, 0xc5, 0xd9, 0x4e, 0x97, 0xa6, 0xe7,
    0xf3, 0x4d, 0xb2, 0x24, 0x9f, 0x96, 0x28, 0x59,
    0xd2, 0x42, 0xeb, 0x07, 0x51, 0xc0, 0xd2, 0xbd
};
static unsigned char const sparkle512_input[] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f,
    0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27,
    0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x2d, 0x2e, 0x2f,
    0x30, 0x31, 0x32, 0x33, 0x34, 0x35, 0x36, 0x37,
    0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x3d, 0x3e, 0x3f
};
static unsigned char const sparkle512_output[] = {
    0x97, 0xa3, 0xeb, 0xa4, 0x69, 0xbc, 0x01, 0x8f,
    0x68, 0xe5, 0xc0, 0x4b, 0x3a, 0x55, 0xe0, 0x3a,
    0x8f, 0x23, 0xfb, 0x39, 0x0f, 0xdb, 0x11, 0x50,
    0xb3, 0x95, 0xd7, 0x95, 0xfa, 0x8c, 0xea, 0x17,
    0x8d, 0x12, 0xc7, 0x22, 0x91, 0x18, 0x14, 0xbe,
    0xf7, 0x8d, 0xe3, 0xf0, 0xcc, 0x65, 0xed, 0xd4,
    0x54, 0xad, 0x58, 0xf0, 0xa8, 0x73, 0x8f, 0x00,
    0x46, 0xf1, 0xcc, 0xbd, 0xfb, 0x8d, 0x09, 0xf1
};

void test_sparkle(void)
{
    uint32_t state256[SPARKLE_256_STATE_SIZE];
    uint32_t state384[SPARKLE_384_STATE_SIZE];
    uint32_t state512[SPARKLE_512_STATE_SIZE];

    printf("SPARKLE Permutation:\n");

    printf("    SPARKLE-256 ... ");
    fflush(stdout);
    memcpy(state256, sparkle256_input, sizeof(sparkle256_input));
    sparkle_256(state256, 10);
    if (!test_memcmp((unsigned char *)state256, sparkle256_output, sizeof(sparkle256_output))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    SPARKLE-384 ... ");
    fflush(stdout);
    memcpy(state384, sparkle384_input, sizeof(sparkle384_input));
    sparkle_384(state384, 11);
    if (!test_memcmp((unsigned char *)state384, sparkle384_output, sizeof(sparkle384_output))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    SPARKLE-512 ... ");
    fflush(stdout);
    memcpy(state512, sparkle512_input, sizeof(sparkle512_input));
    sparkle_512(state512, 12);
    if (!test_memcmp((unsigned char *)state512, sparkle512_output, sizeof(sparkle512_output))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("\n");
}
