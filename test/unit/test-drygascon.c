/*
 * Copyright (C) 2020 Southern Storm Software, Pty Ltd.
 *
 * Permission is hereby granted, free of charge, to any person obtaining a
 * copy of this software and associated documentation files (the "Software"),
 * to deal in the Software without restriction, including without limitation
 * the rights to use, copy, modify, merge, publish, distribute, sublicense,
 * and/or sell copies of the Software, and to permit persons to whom the
 * Software is furnished to do so, subject to the following conditions:
 *
 * The above copyright notice and this permission notice shall be included
 * in all copies or substantial portions of the Software.
 *
 * THE SOFTWARE IS PROVIDED "AS IS", WITHOUT WARRANTY OF ANY KIND, EXPRESS
 * OR IMPLIED, INCLUDING BUT NOT LIMITED TO THE WARRANTIES OF MERCHANTABILITY,
 * FITNESS FOR A PARTICULAR PURPOSE AND NONINFRINGEMENT. IN NO EVENT SHALL THE
 * AUTHORS OR COPYRIGHT HOLDERS BE LIABLE FOR ANY CLAIM, DAMAGES OR OTHER
 * LIABILITY, WHETHER IN AN ACTION OF CONTRACT, TORT OR OTHERWISE, ARISING
 * FROM, OUT OF OR IN CONNECTION WITH THE SOFTWARE OR THE USE OR OTHER
 * DEALINGS IN THE SOFTWARE.
 */

#include "internal-drysponge.h"
#include "test-cipher.h"
#include <stdio.h>
#include <string.h>

/* Number of rounds to perform for the test vectors */
#define GASCON_NUM_ROUNDS 12

/* Test vectors for GASCON generated with the DryGASCON reference code */
static unsigned char const gascon128_input[] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f,
    0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27
};
static unsigned char const gascon128_output[] = {
    0x97, 0x49, 0xac, 0x0d, 0xe8, 0x26, 0x7f, 0xc6,
    0x50, 0xf7, 0x28, 0x5f, 0xe8, 0xf7, 0xb8, 0xb1,
    0x38, 0x85, 0x6a, 0x2f, 0xc6, 0x5b, 0xf3, 0xd5,
    0x91, 0x12, 0x21, 0x91, 0x0d, 0x18, 0x6c, 0x19,
    0x21, 0x7a, 0xba, 0xdd, 0x24, 0xa9, 0x82, 0xee
};
static unsigned char const gascon128_squeezed[] = {
    0x87, 0xe9, 0xea, 0xdd, 0x8c, 0xc7, 0x17, 0x68,
    0x79, 0xbe, 0x72, 0x24, 0x42, 0xea, 0xcf, 0xa3
};
static unsigned char const gascon256_input[] = {
    0x00, 0x01, 0x02, 0x03, 0x04, 0x05, 0x06, 0x07,
    0x08, 0x09, 0x0a, 0x0b, 0x0c, 0x0d, 0x0e, 0x0f,
    0x10, 0x11, 0x12, 0x13, 0x14, 0x15, 0x16, 0x17,
    0x18, 0x19, 0x1a, 0x1b, 0x1c, 0x1d, 0x1e, 0x1f,
    0x20, 0x21, 0x22, 0x23, 0x24, 0x25, 0x26, 0x27,
    0x28, 0x29, 0x2a, 0x2b, 0x2c, 0x2d, 0x2e, 0x2f,
    0x30, 0x31, 0x32, 0x33, 0x34, 0x35, 0x36, 0x37,
    0x38, 0x39, 0x3a, 0x3b, 0x3c, 0x3d, 0x3e, 0x3f,
    0x40, 0x41, 0x42, 0x43, 0x44, 0x45, 0x46, 0x47
};
static unsigned char const gascon256_output[] = {
    0x44, 0x51, 0x6c, 0x30, 0x52, 0x18, 0x16, 0x38,
    0xff, 0xcf, 0x0a, 0x8e, 0x0e, 0xbc, 0xb4, 0xbc,
    0x8b, 0x11, 0x3a, 0xcd, 0xd6, 0x47, 0x61, 0xd6,
    0x48, 0xa2, 0xc8, 0xfa, 0x4d, 0x42, 0x7e, 0x8a,
    0xf6, 0x65, 0x70, 0x39, 0xf2, 0x03, 0x8a, 0x41,
    0x10, 0xcc, 0xcb, 0xbf, 0xd1, 0x6c, 0x49, 0x43,
    0xeb, 0x5a, 0xb2, 0x8b, 0x13, 0x84, 0x93, 0x13,
    0x49, 0xa7, 0x6a, 0x42, 0xd1, 0x3a, 0xfc, 0x8c,
    0x67, 0xb2, 0xe2, 0xab, 0x18, 0xeb, 0x4f, 0x8f
};
static unsigned char const gascon256_squeezed[] = {
    0xaa, 0x10, 0xc7, 0x86, 0x39, 0x65, 0xf0, 0x6f,
    0x5b, 0xde, 0xbc, 0xb3, 0x8d, 0x86, 0x61, 0xd1
};

/* Test vectors for the F function of the DrySPONGE */
static unsigned char const gascon_f_x[] = {
    0x52, 0x93, 0x4a, 0x6c, 0x56, 0x75, 0x4e, 0x6d, /* randomly generated */
    0x98, 0x2b, 0x4c, 0x55, 0x9e, 0xc3, 0x93, 0x05
};
static unsigned char const gascon_f_data[] = {
    0x1f, 0x24, 0x0f, 0x06, 0xb9, 0x72, 0x47, 0x19, /* randomly generated */
    0xad, 0x56, 0x5d, 0xa4, 0xd2, 0x7d, 0x9e, 0x60
};
static unsigned char const gascon128_f_output[] = {
    0xa8, 0xf9, 0xd3, 0x06, 0x0c, 0x48, 0x88, 0x91,
    0x42, 0x55, 0xdc, 0x2f, 0xe4, 0x95, 0x5f, 0xa3,
    0x32, 0xc6, 0x87, 0x60, 0x7a, 0xdf, 0xe5, 0x5b,
    0xf1, 0x7e, 0x8f, 0x20, 0xed, 0xa4, 0x9e, 0x41,
    0x35, 0x26, 0x73, 0x22, 0x60, 0xd6, 0x68, 0x40
};
static unsigned char const gascon128_f_squeezed[] = {
    0xcc, 0x7a, 0xa2, 0xab, 0xf0, 0x28, 0x58, 0x3b,
    0xbf, 0x7b, 0xc7, 0x29, 0x4d, 0x9c, 0x55, 0x74
};
#define gascon128_f_domain 0x600
static unsigned char const gascon256_f_output[] = {
    0x6e, 0xd2, 0x29, 0x2e, 0x0d, 0x34, 0x34, 0x4c,
    0x6e, 0x8e, 0x93, 0xef, 0xab, 0x9e, 0x93, 0xaf,
    0x83, 0x09, 0x59, 0x31, 0x47, 0x51, 0x0c, 0x3e,
    0xae, 0xad, 0xcb, 0xf5, 0x6b, 0xe2, 0x98, 0xb4,
    0x57, 0x77, 0x9a, 0x7c, 0x31, 0xa1, 0xd4, 0x93,
    0xf3, 0x8d, 0xc6, 0x41, 0x99, 0xfe, 0xa6, 0xb4,
    0x23, 0x52, 0x3e, 0x83, 0x85, 0x18, 0xfa, 0x68,
    0xb3, 0x6f, 0x8a, 0x77, 0x69, 0x7a, 0x9e, 0x8f,
    0x9b, 0x6c, 0xed, 0xce, 0x70, 0xc5, 0x23, 0x21
};
static unsigned char const gascon256_f_squeezed[] = {
    0xbd, 0xd0, 0xa4, 0xea, 0xc6, 0x85, 0xa2, 0xf6,
    0xa8, 0x0b, 0x12, 0x69, 0xab, 0xac, 0x46, 0x6f
};
#define gascon256_f_domain 0x18

/* Test vectors for the key setup function of the DrySPONGE */
static unsigned char const gascon128_k_c[] = {
    0xc0, 0x5d, 0x7e, 0xa9, 0xbf, 0xa1, 0x43, 0xb9,
    0xaa, 0x08, 0xf5, 0x70, 0x52, 0x55, 0x54, 0x19,
    0x71, 0x6d, 0xc7, 0x56, 0xd2, 0x82, 0x00, 0x6c,
    0x9f, 0xb4, 0x5c, 0x31, 0x5b, 0xfe, 0x1b, 0x45,
    0xed, 0xda, 0x7b, 0x1e, 0x70, 0x58, 0xff, 0xf7
};
static unsigned char const gascon128_k_x[] = {
    0xfa, 0x8e, 0xc1, 0x86, 0x9c, 0xd9, 0x16, 0x6f,
    0xd9, 0x29, 0x37, 0x29, 0xf9, 0x18, 0x19, 0x19
};
static unsigned char const gascon256_k_c[] = {
    0xbf, 0x34, 0x9e, 0x14, 0x0b, 0x43, 0x1d, 0xf9,
    0x7c, 0x61, 0xdb, 0xe6, 0x2e, 0x64, 0x7d, 0x1a,
    0xd0, 0xe1, 0x9a, 0xfe, 0x1b, 0x78, 0xe4, 0x50,
    0xf8, 0xd9, 0x27, 0x4b, 0x39, 0x8b, 0x8c, 0x9f,
    0xa0, 0xec, 0xde, 0x8d, 0xe9, 0x75, 0x03, 0x88,
    0xe6, 0xe8, 0x0d, 0x73, 0x2b, 0xcf, 0x27, 0x7f,
    0x78, 0x05, 0x8f, 0xe4, 0x51, 0xa2, 0x5c, 0xe0,
    0x1c, 0x0c, 0x0e, 0x50, 0x49, 0x98, 0x35, 0xc6,
    0x94, 0x86, 0x7d, 0xb4, 0xa4, 0x09, 0xf6, 0x14
};
static unsigned char const gascon256_k_x[] = {
    0x0a, 0x8e, 0x01, 0x85, 0x9c, 0xd9, 0x16, 0x53,
    0x7b, 0x7b, 0x7b, 0x7b, 0x2b, 0x2b, 0x2b, 0x2b
};

void test_drygascon(void)
{
    drysponge128_state_t state128;
    drysponge256_state_t state256;

    printf("DryGASCON:\n");

    printf("    GASCON-128 ... ");
    fflush(stdout);
    memcpy(state128.c.B, gascon128_input, sizeof(gascon128_input));
    state128.rounds = GASCON_NUM_ROUNDS;
    drysponge128_g_core(&state128);
    if (!test_memcmp(state128.c.B, gascon128_output, sizeof(gascon128_output))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    GASCON-256 ... ");
    fflush(stdout);
    memcpy(state256.c.B, gascon256_input, sizeof(gascon256_input));
    state256.rounds = GASCON_NUM_ROUNDS;
    drysponge256_g_core(&state256);
    if (!test_memcmp(state256.c.B, gascon256_output, sizeof(gascon256_output))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    DrySPONGE-128-G ... ");
    fflush(stdout);
    memcpy(state128.c.B, gascon128_input, sizeof(gascon128_input));
    drysponge128_g(&state128);
    if (!test_memcmp(state128.c.B, gascon128_output, sizeof(gascon128_output)) &&
        !test_memcmp(state128.r.B, gascon128_squeezed, sizeof(gascon128_squeezed))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    DrySPONGE-256-G ... ");
    fflush(stdout);
    memcpy(state256.c.B, gascon256_input, sizeof(gascon256_input));
    drysponge256_g(&state256);
    if (!test_memcmp(state256.c.B, gascon256_output, sizeof(gascon256_output)) &&
        !test_memcmp(state256.r.B, gascon256_squeezed, sizeof(gascon256_squeezed))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    DrySPONGE-128-F ... ");
    fflush(stdout);
    memcpy(state128.c.B, gascon128_input, sizeof(gascon128_input));
    memcpy(state128.x.B, gascon_f_x, sizeof(gascon_f_x));
    state128.domain = gascon128_f_domain;
    //drysponge128_f_absorb(&state128, gascon_f_data, sizeof(gascon_f_data));
    //drysponge128_g(&state128);
    drygascon128_f_wrap(&state128, gascon_f_data, sizeof(gascon_f_data));
    if (!test_memcmp(state128.c.B, gascon128_f_output, sizeof(gascon128_f_output)) &&
        !test_memcmp(state128.r.B, gascon128_f_squeezed, sizeof(gascon128_f_squeezed))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    DrySPONGE-256-F ... ");
    fflush(stdout);
    memcpy(state256.c.B, gascon256_input, sizeof(gascon256_input));
    memcpy(state256.x.B, gascon_f_x, sizeof(gascon_f_x));
    state256.domain = gascon256_f_domain;
    drysponge256_f_absorb(&state256, gascon_f_data, sizeof(gascon_f_data));
    drysponge256_g(&state256);
    if (!test_memcmp(state256.c.B, gascon256_f_output, sizeof(gascon256_f_output)) &&
        !test_memcmp(state256.r.B, gascon256_f_squeezed, sizeof(gascon256_f_squeezed))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    DrySPONGE-128-Key ... ");
    fflush(stdout);
    drysponge128_setup(&state128, gascon128_input, 16, gascon128_input + 16, 0);
    if (!test_memcmp(state128.c.B, gascon128_k_c, sizeof(gascon128_k_c)) &&
        !test_memcmp(state128.x.B, gascon128_k_x, sizeof(gascon128_k_x))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("    DrySPONGE-256-Key ... ");
    fflush(stdout);
    drysponge256_setup(&state256, gascon256_input, gascon256_input + 32, 0);
    if (!test_memcmp(state256.c.B, gascon256_k_c, sizeof(gascon256_k_c)) &&
        !test_memcmp(state256.x.B, gascon256_k_x, sizeof(gascon256_k_x))) {
        printf("ok\n");
    } else {
        printf("failed\n");
        test_exit_result = 1;
    }

    printf("\n");
}
